Commit message: Edited panda_hand collisions

File: config/panda_arm_hand.urdf (robot description, URDF)
Before this commit: robot panda, 12 links, 11 joints
Links:
- link panda_hand: geometry collision cylinder length=0.15 radius=0.015; collision cylinder length=0.15 radius=0.015
